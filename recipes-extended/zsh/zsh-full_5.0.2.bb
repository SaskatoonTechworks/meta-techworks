require zsh-full.inc
DEPENDS = "ncurses libcap libpcre groff-native"

SRC_URI[md5sum] = "19466d778777fe7f36e89b3b3c8613c1"
SRC_URI[sha256sum] = "adc0c7881532419797713b7c503bcc5674c88f93a191e26f700b42c11a1a816e"
